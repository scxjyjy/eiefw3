# IAR project anttt-SD3-SDK6_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51422-QFAA NordicSemi nRF51422-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NRF51
  ICCARM.CCIncludePath2: ..\bsp; ..\application; ..\nordic_sdk6_1_0; ..\nordic_sdk6_1_0\Include; ..\nordic_sdk6_1_0\Include\s310; ..\nordic_sdk6_1_0\Include\ble; ..\nordic_sdk6_1_0\Include\ble\ble_services; ..\nordic_sdk6_1_0\Include\ble\device_manager; ..\nordic_sdk6_1_0\Include\app_common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\bsp
  OBJCOPY.OOCOutputFile: anttt-SD3-SDK6_1.hex
  ILINK.IlinkOutputFile: anttt-SD3-SDK6_1.out
  ILINK.IlinkIcfFile: ..\bsp\nRF51422_QFAA.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group _BSP
    ../bsp/: anttt-eief1-01.c
  group _BSP/Include
    ../bsp/: ant_integration.h anttt-eief1-01.h ble_integration.h bleperipheral.h configuration.h interrupts.h leds_anttt.h soc_integration.h utilities.h
  group _BSP/Source
    ../bsp/: ant_integration.c ble_integration.c bleperipheral.c interrupts.c leds_anttt.c soc_integration.c utilities.c
  group _Nordic_SDK_6_1_0
    ../../../../../Desktop/: spi-Master.c
    ../nordic_sdk6_1_0/: spi_master.c
  group _Nordic_SDK_6_1_0/Include
    ../nordic_sdk6_1_0/Include/s310/: ant_error.h ant_interface.h ant_parameters.h ble.h ble_gap.h ble_gatts.h ble_types.h nrf_sdm.h nrf_soc.h
    ../nordic_sdk6_1_0/Include/ble/: ble_advdata.h ble_advdata_parser.h
    ../nordic_sdk6_1_0/Include/: nordic_common.h nrf.h nrf51.h nrf_assert.h nrf_delay.h nrf_gpio.h nrf_gpiote.h
    ../../../../../Desktop/: spi-Master.h
  group _Nordic_SDK_6_1_0/Source
    ../nordic_sdk6_1_0/: ble_advdata.c ble_advdata_parser.c iar_startup_nrf51.s system_nrf51422.c
  group Application/Include
    ../application/: anttt.h bleperipheral_engenuics.h main.h typedefs.h
  group Application/Source
    ../application/: anttt.c bleperipheral_engenuics.c main.c
